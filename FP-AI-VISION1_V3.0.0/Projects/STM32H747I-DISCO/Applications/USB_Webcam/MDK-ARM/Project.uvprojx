# Keil uVision project Project.uvprojx, settings and files
target STM32H747I_DISCO_CM7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.0
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H747I_DISCO_CM7 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_DISCO,CORE_CM7,USE_USB_HS,DATA_IN_ExtSDRAM
  c include: ../Common/Inc;../CM7/Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../Common/Extension/Drivers/BSP/STM32H747I-Discovery;../../../../../Drivers/BSP/STM32H747I-Discovery;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/Components/ov5640;../../../../../Drivers/BSP/Components/ov9655;../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../Utilities/JPEG
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: stm32h747xx_flash_CM7.sct
  group Application/MDK-ARM
    ./: startup_stm32h747xx.s
  group Application/User/CM7
    ../CM7/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c usbd_conf.c usbd_desc.c usbd_video.c usbd_video_if.c
  group Doc
    ../: README.md
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
    ../../../../../Drivers/BSP/Components/ov9655/: ov9655.c ov9655_reg.c
    ../../../../../Drivers/BSP/Components/ov5640/: ov5640.c ov5640_reg.c
  group Drivers/BSP/STM32H747I_DISCO
    ../../../../../Drivers/BSP/STM32H747I-Discovery/: stm32h747i_discovery.c stm32h747i_discovery_bus.c stm32h747i_discovery_camera.c stm32h747i_discovery_sdram.c
    ../CM7/Src/: stm32h747i_discovery_camera_ex.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sram.c stm32h7xx_ll_fmc.c stm32h7xx_ll_usb.c
  group Middlewares/STM32_USB_Device_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Utilities/JPEG
    ../../../../../Utilities/JPEG/: jpeg_utils.c
software components: CMSIS:CORE 4.3.0
